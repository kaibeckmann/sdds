# IAR project at3290p.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x50
  General.SCCStackSize: 0x100
  General.SCRStackSize: 100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: AVR; AVRRAVEN_3290P; __ATmega3290P__; AVRRAVEN_3290P_APP_REV_MAJ=1; AVRRAVEN_3290P_APP_REV_MIN=1; F_CPU=4000000UL; ENABLE_BIT_DEFINITIONS
  ICCAVR.newCCIncludePaths: ..\configure\arch; ..\configure\arch\avr\dev; ..\configure\application\avrraven; ..\configure\application\avrraven\3290p; ..\configure\application\avrraven\3290p\drivers; ..\configure\application\avrraven\3290p\board_peripherals; ..\include\application\avrraven; ..\board; ..\include\application\avrraven\3290p; ..\include; ..\include\vrt; ..\include\arch\avr; ..\include\application\avrraven\3290p\drivers; ..\include\application\avrraven\3290p\menu; ..\include\application\avrraven\3290p\board_peripherals; ..\configure\vrt; ..\..\include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm3290p.xcl
  group application
    ../application/avrraven/3290p/: asy_tmr.c avrraven_3290p.c battery.c bcd.c cmd_if_3290p.c extern_sipc_cmd.c int_evt.c tick.c
  group application/board_peripherals
    ../application/avrraven/3290p/board_peripherals/: lcd.c led.c temp.c
  group application/drivers
    ../application/avrraven/3290p/drivers/: adc.c spi.c
  group arch
    ../arch/avr/dev/: sipc.c
  group include
    ../board/: board_avrraven_3290p.h
    ../include/: compiler.h
    ../../include/: sipc.h sipcproto.h
  group include/application
    ../include/application/avrraven/: macros.h rvn_loc.h
  group include/application/3290P
    ../include/application/avrraven/3290p/: asy_tmr.h avrraven_3290p.h battery.h bcd.h cmd_if_3290p.h error.h extern_sipc_cmd.h int_evt.h loc.h tick.h
  group include/application/3290P/board_peripherals
    ../include/application/avrraven/3290p/board_peripherals/: lcd.h led.h temp.h
  group include/application/3290P/drivers
    ../include/application/avrraven/3290p/drivers/: adc.h spi.h
  group include/arch
    ../include/arch/avr/: compiler_avr.h eep.h sipc.h sleep_avr.h wdt_avr.h
  group include/vrt
    ../include/vrt/: vrt_kernel.h vrt_mem.h
  group vrt
    ../vrt/: vrt_kernel.c vrt_mem.c
